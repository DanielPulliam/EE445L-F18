# Keil uVision project Lab 2 - Copy.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab 2
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source Group 1
    ./: startup.s ADCSWTrigger.c ADCTestMain.c PLL.c ADCSWTrigger.h PLL.h ST7735.h tm4c123gh6pm.h ST7735.c Timer1.c Timer1.h
